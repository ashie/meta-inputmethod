FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-desktop-shell-reposition-mapped-input-panel-surfaces.patch"

